# Keil uVision project brain_mcu.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: SAM4SD32C Atmel
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0x400000-0x4FFFFF) IROM2(0x500000-0x5FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")
  output: brain_mcu
  c flags: Optim=1
  c define: __UART
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT5: ROM 0x500000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Source Group 1
    ./: startup_SAM4S.s system_SAM4S.c Retarget.c BTN.c LED.c Serial.c commands.c brain_mcu.c
