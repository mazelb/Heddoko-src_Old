# Keil uVision project brain_mcu.uvprojx, settings and files
target ATMEL SAM4S Xplained Pro (ARM-ADS)
  device: ATSAM4SD32C Atmel
  pack: Keil.SAM4_DFP.1.3.0
  cpu: IROM(0x00400000,0x100000) IROM2(0x00500000,0x100000) IRAM(0x20000000,0x28000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: brain_mcu
  c flags: Optim=1
  c define: __UART
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT5: ROM 0x500000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group BSP
    ./: File_Config.c MCI_SAM4S.c system_SAM4S.c startup_SAM4S.s
    ./CM4/DeviceSupport/ARM/ARMCM4/: RTX_Conf_ARMCM4.c
  group Library
    C:/Keil_v5/ARM/RV31/LIB/: FS_CM3.lib
  group SD Card
    ./: SDcard_functionality.c
  group IO
    ./: Serial.c UART_functionality.c Button.c LED.c
  group Heddoko Code
    ./: Retarget.c Main.c Tasks.c commands.c BrainMCU.c
